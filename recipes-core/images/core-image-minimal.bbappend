
OVERRIDES_append = ":${OF_TYPE}"

IMAGE_INSTALL_append = " \
    openfiles \
    openfiles-test \
"

IMAGE_INSTALL_append_smb = " \
    smbcp \
"
